# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104ML RL78 - R5F104ML
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 160
  General.GenNearHeapSize: 0
  General.GenFarHeapSize: 0
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: RL78_G14_FPB; RENESAS_SIMULATOR_DEBUGGING
  ICCRL78.CCDiagSuppress: Pa091,Pe177,Pe082,Ta026,Pa082
  ICCRL78.CCIncludePath2: applilet3_src; src\frtos_config; src\frtos_startup; src\frtos_skeleton; src\FreeRTOS_Demo; ..\Common\include; ..\..\Source\portable\IAR\RL78; ..\..\Source\include; src
  ARL78.AsmIncludePath: src\frtos_config; src\FreeRTOS_Demo; ..\..\Source\portable\IAR\RL78
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group (top)
    ./: Applilet3.ipcf
  group FreeRTOS
    ../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ../../Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group FreeRTOS/portable
    ../../Source/portable/IAR/RL78/: ISR_Support.h port.c portasm.s portmacro.h
  group FreeRTOS/portable/MemMang
    ../../Source/portable/MemMang/: heap_1.c
  group FreeRTOS_Demo
    src/FreeRTOS_Demo/: demo_main.h demo_specific_io.h
  group FreeRTOS_Demo/Blinky_Demo
    src/FreeRTOS_Demo/Blinky_Demo/: main_blinky.c
  group FreeRTOS_Demo/Full_Demo
    src/FreeRTOS_Demo/Full_Demo/: main_full.c RegTest.s
  group FreeRTOS_Demo/Full_Demo/Standard_Demo_Tasks
    ../Common/Minimal/: blocktim.c dynamic.c PollQ.c
  group frtos_config
    src/frtos_config/: FreeRTOSConfig.h
  group frtos_skeleton
    src/frtos_skeleton/: main_task.c task_CONIO.c task_function.h task_LED0.c task_LED1.c
  group frtos_startup
    src/frtos_startup/: freertos_isr.h freertos_object_init.c freertos_start.c freertos_start.h
  group Renesas_AP/cg_src
    applilet3_src/: r_cg_cgc.c r_cg_cgc_user.c r_cg_dtc.c r_cg_dtc_user.c r_cg_intc.c r_cg_intc_user.c r_cg_port.c r_cg_port_user.c r_cg_serial.c r_cg_serial_user.c r_main.c r_systeminit.c
  group RenesasSimDebug
    src/RenesasSimDebug/: sim_debug_mode_hook.c sim_debug_mode_hook.h sim_debugger_console.c
  group Src
    src/: ExampleISR.s platform.h rl78g14_fpb_main.c rl78g14fpbdef.h
