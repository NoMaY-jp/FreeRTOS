# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R7F100GLG RL78 - R7F100GLG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 160
  General.GenNearHeapSize: 0
  General.GenFarHeapSize: 0
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: RL78_G23_FPB; RENESAS_SIMULATOR_DEBUGGING; EWRL78_16K_KICKSTART_EDITION
  ICCRL78.CCDiagSuppress: Pa091,Pe177
  ICCRL78.CCIncludePath2: applilet3_src; ..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI; ..\Common\include; src\FreeRTOS_Demo\Full_Demo; src\FreeRTOS_Demo; ..\..\Source\portable\IAR\RL78; ..\..\Source\include; src\frtos_skeleton; src\frtos_startup; src\frtos_config; src; src\smc_integration; src\smc_gen\Config_DTC; src\smc_gen\Config_INTC; src\smc_gen\Config_ITL0; src\smc_gen\Config_PORT; src\smc_gen\Config_UART1; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config
  ARL78.AsmIncludePath: src\FreeRTOS_Demo; ..\..\Source\portable\IAR\RL78; src\frtos_config; src\smc_integration
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: SmartConfigurator.ipcf
  group FreeRTOS
    ../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ../../Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group FreeRTOS/portable
    ../../Source/portable/IAR/RL78/: ISR_Support.h port.c portasm.s portmacro.h
  group FreeRTOS/portable/MemMang
    ../../Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c ReadMe.url
  group FreeRTOS_Demo
    src/FreeRTOS_Demo/: demo_main.h demo_specific_io.h
  group FreeRTOS_Demo/Blinky_Demo
    src/FreeRTOS_Demo/Blinky_Demo/: main_blinky.c
  group FreeRTOS_Demo/Full_Demo
    src/FreeRTOS_Demo/Full_Demo/: main_full.c RegTest.s serial.c
  group FreeRTOS_Demo/Full_Demo/FreeRTOS+CLI
    ../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
    ../../../FreeRTOS-Plus/Demo/Common/FreeRTOS_Plus_CLI_Demos/: Sample-CLI-commands.c UARTCommandConsole.c
  group FreeRTOS_Demo/Full_Demo/Standard_Demo_Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c IntQueue.c IntSemTest.c QueueOverwrite.c recmutex.c semtest.c TaskNotify.c TaskNotifyArray.c TimerDemo.c
  group frtos_config
    src/frtos_config/: FreeRTOSConfig.h
  group frtos_skeleton
    src/frtos_skeleton/: main_task.c task_CONIO.c task_function.h task_LED0.c task_LED1.c
  group frtos_startup
    src/frtos_startup/: freertos_helper.c freertos_helper.h freertos_object_init.c freertos_stack.h freertos_start.c freertos_start.h
  group Renesas_SC/smc_gen/Config_DTC
    src/smc_gen/Config_DTC/: Config_DTC.c Config_DTC.h Config_DTC_user.c
  group Renesas_SC/smc_gen/Config_INTC
    src/smc_gen/Config_INTC/: Config_INTC.c Config_INTC.h Config_INTC_user.c
  group Renesas_SC/smc_gen/Config_ITL0
    src/smc_gen/Config_ITL0/: Config_ITL0.c Config_ITL0.h Config_ITL0_user.c
  group Renesas_SC/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_SC/smc_gen/Config_UART1
    src/smc_gen/Config_UART1/: Config_UART1.c Config_UART1.h Config_UART1_user.c
  group Renesas_SC/smc_gen/general
    src/smc_gen/general/: r_cg_dtc.h r_cg_dtc_common.c r_cg_dtc_common.h r_cg_intc.h r_cg_itl.h r_cg_itl_common.c r_cg_itl_common.h r_cg_itl_common_user.c r_cg_lvd.h r_cg_lvd_common.c r_cg_lvd_common.h r_cg_lvd_common_user.c r_cg_macrodriver.h r_cg_port.h r_cg_sau.h r_cg_sau_common.c r_cg_sau_common.h r_cg_systeminit.c r_cg_userdefine.h r_smc_entry.h
  group Renesas_SC/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_SC/smc_gen/r_bsp/board/generic_rl78_g23
    src/smc_gen/r_bsp/board/generic_rl78_g23/: hdwinit.c hdwinit.h r_bsp.h r_bsp_config_reference.h r_bsp_init.c
  group Renesas_SC/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an5522ej0100-rl78.pdf
  group Renesas_SC/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an5522jj0100-rl78.pdf
  group Renesas_SC/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: cstartup.s r_bsp_common.c r_bsp_common.h r_bsp_rl78_compiler.h
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_g23
    src/smc_gen/r_bsp/mcu/rl78_g23/: mcu_clocks.c mcu_clocks.h mcu_info.h vecttbl.c
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_g23/register_access/iccrl
    src/smc_gen/r_bsp/mcu/rl78_g23/register_access/iccrl/: intrinsics.h ior7f100g.h ior7f100g_ext.h
  group Renesas_SC/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h
  group Renesas_SC_tips
    src/smc_integration/: BSP_patch.c ior7f100g.h ior7f100g_ext.h smc_integration.h
  group Renesas_SC_tips/smc_integration/RenesasSimDebug
    src/smc_integration/RenesasSimDebug/: sim_debug_mode_hook.c sim_debug_mode_hook.h sim_debugger_console.c
  group Src
    src/: rl78g23_fpb_main.c rl78g23fpbdef.h UART1.c UART1.h UART1.txt
