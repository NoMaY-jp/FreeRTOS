# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 0
  General.GenFarHeapSize: 0
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCDiagSuppress: Pa082
  ICCRL78.CCIncludePath2: ..\..\Source\include; ..\Common\include; $PROJ_DIR$; ..\..\Source\portable\IAR\RL78
  ARL78.AsmIncludePath: ..\..\Source\portable\IAR\RL78; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  group Demo Source
    ./: main.c RegTest.s
  group Demo Source/StandardDemos
    ../Common/Minimal/: blocktim.c dynamic.c PollQ.c
  group Kernel Source
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/: list.c queue.c tasks.c timers.c
    ../../Source/portable/IAR/RL78/: port.c portasm.s
