# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F572NN R5F572NN
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0
  General.IStackSize: 0x400
  General.HeapSize: 0
  ICCRX.CCDefines: __RX; ideDISABLE_DEBUG_CONSOLE
  ICCRX.CCDiagSuppress: Pa091,Pe177
  ICCRX.CCIncludePath2: ..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI; ..\Common\include; src\FreeRTOS_Demo\Full_Demo; src\FreeRTOS_Demo; src; src\smc_workaround; ..\..\Source\include; ..\..\Source\portable\IAR\RX; src\frtos_startup; src\frtos_config; src\frtos_skeleton; src\smc_gen\r_bsp; src\smc_gen\r_byteq; src\smc_gen\r_byteq\src; src\smc_gen\r_config; src\smc_gen\r_dtc_rx; src\smc_gen\r_dtc_rx\src; src\smc_gen\r_gpio_rx; src\smc_gen\r_gpio_rx\src; src\smc_gen\r_sci_rx; src\smc_gen\r_sci_rx\src; src\smc_gen\general; src\smc_gen\r_pincfg
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\; src
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: SmartConfigurator.ipcf
  group FreeRTOS
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/include
    ../../Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group FreeRTOS/portable
    ../../Source/portable/IAR/RX/: port.c portmacro.h
  group FreeRTOS/portable/MemMang
    ../../Source/portable/MemMang/: heap_4.c
  group FreeRTOS_Demo
    src/FreeRTOS_Demo/: demo_main.h demo_specific_io.h
  group FreeRTOS_Demo/Blinky_Demo
    src/FreeRTOS_Demo/Blinky_Demo/: main_blinky.c
  group FreeRTOS_Demo/Full_Demo
    src/FreeRTOS_Demo/Full_Demo/: IntQueueTimer.c IntQueueTimer.h main_full.c serial.c
  group FreeRTOS_Demo/Full_Demo/FreeRTOS+CLI
    ../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
    ../../../FreeRTOS-Plus/Demo/Common/FreeRTOS_Plus_CLI_Demos/: Sample-CLI-commands.c UARTCommandConsole.c
  group FreeRTOS_Demo/Full_Demo/Standard_Demo_Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c IntQueue.c IntSemTest.c QueueOverwrite.c recmutex.c semtest.c TaskNotify.c TaskNotifyArray.c TimerDemo.c
  group frtos_config
    src/frtos_config/: FreeRTOSConfig.h
  group frtos_skeleton
    src/frtos_skeleton/: task_function.h
  group frtos_startup
    src/frtos_startup/: freertos_object_init.c freertos_start.c freertos_start.h
  group Renesas_AP/smc_gen/general
    src/smc_gen/general/: r_cg_hardware_setup.c r_cg_macrodriver.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/smc_gen/r_bsp/board/generic_rx72n
    src/smc_gen/r_bsp/board/generic_rx72n/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h
  group Renesas_AP/smc_gen/r_bsp/board/user
    src/smc_gen/r_bsp/board/user/: r_bsp.h
  group Renesas_AP/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an1685ej0564-rx-bsp.pdf
  group Renesas_AP/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an1685jj0564-rx-bsp.pdf
  group Renesas_AP/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: lowlvl.c lowlvl.h lowsrc.c lowsrc.h mcu_locks.c r_bsp_common.c r_bsp_common.h r_bsp_cpu.c r_bsp_interrupts.c r_bsp_interrupts.h r_bsp_locking.c r_bsp_mcu_startup.c r_bsp_mcu_startup.h r_bsp_software_interrupt.c r_bsp_software_interrupt.h r_rtos.h r_rx_compiler.h r_rx_intrinsic_functions.c r_rx_intrinsic_functions.h r_typedefs.h resetprg.c
  group Renesas_AP/smc_gen/r_bsp/mcu/rx72n
    src/smc_gen/r_bsp/mcu/rx72n/: mcu_clocks.c mcu_clocks.h mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h r_bsp_cpu.h r_bsp_locking.h vecttbl.c vecttbl.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx72n/register_access/iccrx
    src/smc_gen/r_bsp/mcu/rx72n/register_access/iccrx/: iodefine.h
  group Renesas_AP/smc_gen/r_byteq
    src/smc_gen/r_byteq/: r_byteq_if.h readme.txt
  group Renesas_AP/smc_gen/r_byteq/doc/en
    src/smc_gen/r_byteq/doc/en/: r01an1683ej0182-rx-apl.pdf
  group Renesas_AP/smc_gen/r_byteq/doc/ja
    src/smc_gen/r_byteq/doc/ja/: r01an1683jj0182-rx-apl.pdf
  group Renesas_AP/smc_gen/r_byteq/ref
    src/smc_gen/r_byteq/ref/: r_byteq_config_reference.h
  group Renesas_AP/smc_gen/r_byteq/src
    src/smc_gen/r_byteq/src/: r_byteq.c r_byteq_private.h
  group Renesas_AP/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h r_byteq_config.h r_dtc_rx_config.h r_gpio_rx_config.h r_sci_rx_config.h
  group Renesas_AP/smc_gen/r_dtc_rx
    src/smc_gen/r_dtc_rx/: r_dtc_rx_if.h readme.txt
  group Renesas_AP/smc_gen/r_dtc_rx/doc/en
    src/smc_gen/r_dtc_rx/doc/en/: r01an1819ej0360-rx-dtc-dmac2.pdf
  group Renesas_AP/smc_gen/r_dtc_rx/doc/ja
    src/smc_gen/r_dtc_rx/doc/ja/: r01an1819jj0360-rx-dtc-dmac2.pdf
  group Renesas_AP/smc_gen/r_dtc_rx/ref
    src/smc_gen/r_dtc_rx/ref/: r_dtc_rx_config_reference.h
  group Renesas_AP/smc_gen/r_dtc_rx/src
    src/smc_gen/r_dtc_rx/src/: r_dtc_rx.c r_dtc_rx_private.h
  group Renesas_AP/smc_gen/r_dtc_rx/src/targets/rx72n
    src/smc_gen/r_dtc_rx/src/targets/rx72n/: r_dtc_rx_target.c r_dtc_rx_target.h r_dtc_rx_target_if.h
  group Renesas_AP/smc_gen/r_gpio_rx
    src/smc_gen/r_gpio_rx/: r_gpio_rx_if.h readme.txt
  group Renesas_AP/smc_gen/r_gpio_rx/doc/en
    src/smc_gen/r_gpio_rx/doc/en/: r01an1721ej0370-rx-gpio.pdf
  group Renesas_AP/smc_gen/r_gpio_rx/doc/ja
    src/smc_gen/r_gpio_rx/doc/ja/: r01an1721jj0370-rx-gpio.pdf
  group Renesas_AP/smc_gen/r_gpio_rx/ref
    src/smc_gen/r_gpio_rx/ref/: r_gpio_rx_config_reference.h
  group Renesas_AP/smc_gen/r_gpio_rx/src
    src/smc_gen/r_gpio_rx/src/: r_gpio_rx.c
  group Renesas_AP/smc_gen/r_gpio_rx/src/targets/rx72n
    src/smc_gen/r_gpio_rx/src/targets/rx72n/: r_gpio_rx72n.c r_gpio_rx72n.h
  group Renesas_AP/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h r_pinset.h r_sci_rx_pinset.c r_sci_rx_pinset.h
  group Renesas_AP/smc_gen/r_sci_rx
    src/smc_gen/r_sci_rx/: r_sci_rx_if.h readme.txt
  group Renesas_AP/smc_gen/r_sci_rx/doc/en
    src/smc_gen/r_sci_rx/doc/en/: r01an1815ej0370-rx-serial.pdf
  group Renesas_AP/smc_gen/r_sci_rx/doc/ja
    src/smc_gen/r_sci_rx/doc/ja/: r01an1815jj0370-rx-serial.pdf
  group Renesas_AP/smc_gen/r_sci_rx/ref
    src/smc_gen/r_sci_rx/ref/: r_sci_rx_config_reference.h
  group Renesas_AP/smc_gen/r_sci_rx/src
    src/smc_gen/r_sci_rx/src/: r_sci_rx.c r_sci_rx_dmaca.c r_sci_rx_dmaca.h r_sci_rx_dtc.c r_sci_rx_dtc.h r_sci_rx_platform.h r_sci_rx_private.h
  group Renesas_AP/smc_gen/r_sci_rx/src/targets/rx72n
    src/smc_gen/r_sci_rx/src/targets/rx72n/: r_sci_rx72n.c r_sci_rx72n_data.c r_sci_rx72n_private.h
  group Renesas_AP_tips/smc_workaround
    src/smc_workaround/: CC_patch.h CG_patch.h FIT_patch.c FIT_patch.h IDE_patch.h smc_workaround.h u_sci_rx_ext.c u_sci_rx_ext_if.h
